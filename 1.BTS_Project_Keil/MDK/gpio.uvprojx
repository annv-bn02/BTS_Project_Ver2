# Keil uVision project gpio.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../USER/: main.c bts_adc.c bts_config_gpio.c bts_convert.c bts_frame_message.c bts_get_message.c bts_sys.c bts_task_io.c bts_task_msg_transmission.c bts_task_sys.c bts_uart.c bts_uart3.c
  group header
    ../USER/: bts_adc.h bts_automatic_control.h bts_config_gpio.h bts_convert.h bts_device.h bts_event_define.h bts_frame_message.h bts_get_message.h bts_mutex_define.h bts_queue_define.h bts_sensor_airconditioner.h bts_sensor_door.h bts_sensor_ntc.h bts_sensor_smoke.h bts_sensor_water.h bts_sys.h bts_task_io.h bts_task_msg_transmission.h bts_task_sys.h bts_uart.h bts_uart3.h systick.h
  group sensor
    ../USER/: bts_sensor_airconditioner.c bts_sensor_door.c bts_sensor_ntc.c bts_sensor_smoke.c bts_sensor_water.c
  group device
    ../USER/: bts_automatic_control.c bts_device.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:EVAL:GD32F30x 2.1.0, Device:GD32F30x_StdPeripherals:ADC 2.1.0, Device:GD32F30x_StdPeripherals:DMA 2.1.0, Device:GD32F30x_StdPeripherals:EXTI 2.1.0, Device:GD32F30x_StdPeripherals:GPIO 2.1.0, Device:GD32F30x_StdPeripherals:MISC 2.1.0, Device:GD32F30x_StdPeripherals:PMU 2.1.0, Device:GD32F30x_StdPeripherals:RCU 2.1.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_libopt 2.1.0, Device:Startup 2.1.0
