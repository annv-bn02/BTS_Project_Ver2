# Keil uVision project gpio.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IROM(0x08000000,0x040000) IRAM(0x20000000,0x0C000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../USER/: main.c systick.c bts_uart.c bts_timer.c bts_flash.c
software components: CMSIS:CORE 5.6.0, Device:EVAL:GD32F30x 2.1.0, Device:GD32F30x_StdPeripherals:ADC 2.1.0, Device:GD32F30x_StdPeripherals:DMA 2.1.0, Device:GD32F30x_StdPeripherals:EXTI 2.1.0, Device:GD32F30x_StdPeripherals:FMC 2.1.0, Device:GD32F30x_StdPeripherals:GPIO 2.1.0, Device:GD32F30x_StdPeripherals:MISC 2.1.0, Device:GD32F30x_StdPeripherals:PMU 2.1.0, Device:GD32F30x_StdPeripherals:RCU 2.1.0, Device:GD32F30x_StdPeripherals:TIMER 2.1.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_libopt 2.1.0, Device:Startup 2.1.0
